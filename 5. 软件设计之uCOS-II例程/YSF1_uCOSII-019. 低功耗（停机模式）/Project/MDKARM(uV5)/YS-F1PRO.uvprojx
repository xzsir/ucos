# Keil uVision project YS-F1PRO.uvprojx, settings and files
target YS-F1PRO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YS-F1PRO +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User;..\..\User\OS;..\..\User\bsp;..\..\uCOSII\uC-CPU;..\..\uCOSII\uC-CPU\ARM-Cortex-M3\RealView;..\..\uCOSII\uC-LIB;..\..\uCOSII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\uCOSII\uCOS-II\Source;..\..\uCOSII\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Derive
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: main.c stm32f10x_it.c
  group bsp
    ../../User/bsp/: bsp.h bsp.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/usart/: bsp_debug_usart.c
  group uCOSII_CPU
    ../../uCOSII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOSII/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uCOSII_LIB
    ../../uCOSII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOSII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOSII_Ports
    ../../uCOSII/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uCOSII_Source
    ../../uCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group OS
    ../../User/OS/: app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group Readme
    ../../Readme/: 01.例程功能说明.txt 02.开发环境说明.txt
